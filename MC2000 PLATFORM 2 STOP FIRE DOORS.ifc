Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 95a8fa8a-5c5b-4794-b34f-d1fcfceb3351, NumberOfSaves: 1]
File name: MHExport.ifc
Time: 2026-07-30T14:51:31+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENU) - IFC 23.4.0.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBuildingElementProxy: BIM Motala Hissar:MasterType, BIM Motala Hissar:MasterType:8046
In: Level 1
Type - Material: Steel, Paint Finish, Ivory, Matte, Glass
Type - Other - Category: Generic Models; Family Name: BIM Motala Hissar
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - pitDepth: 60 mm; shaftDepth: 1560 mm; shaftHeight: 8853 mm; shaftWidth: 1250 mm
Type - Identity Data - Type Name: MasterType
Type - Text - DoorAutoTypes: 0&34603&34603&0&0&0&0&0&0&0&0&0&0&¤34603&0&0&0&0&0&0&0&0&0&0&0&0&¤0&0&0&0&0&0&0&0&0&0&0&0&0&¤0&0&0&0&0&0&0&0&0&0&0&0&0&¤; doorHeights: 0&2260&2160&0&0&0&0&0&0&0&0&0&0&¤2260&0&2160&0&0&0&0&0&0&0&0&0&0&¤0&0&2160&0&0&0&0&0&0&0&0&0&0&¤0&0&2160&0&0&0&0&0&0&0&0&0&0&¤; doorWidths: 900&900&900&0&0&0&0&0&0&0&0&0&0&¤1000&900&1000&0&0&0&0&0&0&0&0&0&0&¤900&900&900&0&0&0&0&0&0&0&0&0&0&¤900&900&1000&0&0&0&0&0&0&0&0&0&0&¤; driveSide: D; glassLists: False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&¤False&False&False&False&True&True&True&True&True&True&True&True&True&True&True&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&¤False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&¤False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&False&¤; glazingOffsets: 0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&0&; intHeights: 2000&2000&2000&0&0&0&0&0&0&0&0&0&0&¤2000&2000&2000&0&0&0&0&0&0&0&0&0&0&¤2000&2000&2000&0&0&0&0&0&0&0&0&0&0&¤2000&2000&2000&0&0&0&0&0&0&0&0&0&0&¤; Justerings: 0&0&0&0&0&0&0&0&0&0&0&0&0&¤34401&0&0&0&0&0&0&0&0&0&0&0&0&¤0&0&0&0&0&0&0&0&0&0&0&0&0&¤0&0&0&0&0&0&0&0&0&0&0&0&0&¤; LeftHangTypes: 0&34101&34101&0&0&0&0&0&0&0&0&0&0&¤34101&0&0&0&0&0&0&0&0&0&0&0&0&¤0&0&0&0&0&0&0&0&0&0&0&0&0&¤0&0&0&0&0&0&0&0&0&0&0&0&0&¤; noOfStops: 3; types: 0&34004&34006&0&0&0&0&0&0&0&0&0&0&¤34006&0&0&0&0&0&0&0&0&0&0&0&0&¤0&0&0&0&0&0&0&0&0&0&0&0&0&¤0&0&0&0&0&0&0&0&0&0&0&0&0&¤; zStartPositions: 0&3268&6587&0&0&0&0&0&0&0&0&0&0&
Pset_BuildingElementProxyCommon - Reference: MasterType; sets with these values: 2
Other - Family: BIM Motala Hissar; Family and Type: BIM Motala Hissar: MasterType; Type: MasterType; Type Id: 8031
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 38.4305 m2; Volume: 1.07133 m3
Phasing - Phase Created: New Construction
